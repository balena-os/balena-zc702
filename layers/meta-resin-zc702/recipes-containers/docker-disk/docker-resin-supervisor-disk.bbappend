LED_FILE_zc702-zynq7 = "/sys/class/leds/ds23/brightness"
